# Keil uVision project MH22G3.uvprojx, settings and files
target T100 (6220000::V6.22::ARMCLANG)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MH22G3 +hex
  c flags: Optim=2 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\Libraries\CMSIS\Lib\ARM;..\Libraries\MH22xxLib\inc;..\Libraries\CMSIS\Include;..\Libraries\CORE;..\Cpuinit;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c mh22xx_it.c
    ../Libraries/MH22xxLib/src/: system_mh22xx.c
  group Library
    ../Libraries/CORE/: startup_mh22xx.s
    ../Libraries/MH22xxLib/src/: misc.c mh22xx_rcc.c mh22xx_gpio.c mh22xx_usart.c mh22xx_exti.c mh22xx_flash.c mh22xx_tim.c mh22xx_adc.c mh22xx_dma.c
    ../SYSTEM/delay/: delay.c
  group Cpuinit
    ../Cpuinit/: adc.c flash.c gpio.c timer.c usart.c rcc.c pwm.c Systick.c
  group Driver
    ../Driver/: board_support.c para.c
